# Keil uVision project Drohne Lendl.uvprojx, settings and files
target Drohne Lendl (6190000::V6.19::ARMCLANG)
  device: STM32H7A3RGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x240FFFFF) IROM(0x8000000-0x807FFFF) IROM2(0x8100000-0x817FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: Drohne Lendl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7A3xx
  c include: ../Core/Inc;C:/Users/Max/STM32Cube/Repository/Packs/STMicroelectronics/X-CUBE-MEMS1/10.0.0/Drivers/BSP/Components/lsm6dso;C:/Users/Max/STM32Cube/Repository/Packs/STMicroelectronics/X-CUBE-MEMS1/10.0.0/Drivers/BSP/Components/lis2mdl;C:/Users/Max/STM32Cube/Repository/Packs/STMicroelectronics/X-CUBE-MEMS1/10.0.0/Drivers/BSP/Components/lps22hh;C:/Users/Max/STM32Cube/Repository/Packs/STMicroelectronics/X-CUBE-MEMS1/10.0.0/Drivers/BSP/Components/Common;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8100000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x100000
  group Application/MDK-ARM
    ./: startup_stm32h7a3xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32h7xx_it.c stm32h7xx_hal_msp.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group DS2438
    ../Core/Src/: DS2438.c
  group Receiver
    ../Core/Src/: receiver.c
  group IMU_10DOF
    ../Core/Src/: IMU_10DOF.c
  group Status_Handling
    ../Core/Src/: status_handling.c
  group PID
    ../Core/Src/: PID.c
  group DShot
    ../Core/Src/: dshot_own.c
  group Data Transmission
    ../Core/Src/: datatransmission.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
