# Keil uVision project DEMO_MPU_9150_REJ.uvprojx, settings and files
target ARM_Minmalsystem (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: DEMO_MPU_9150_REJ
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: DEMO_MPU_9150_REJ.c
  group MPU_Library
    ./: MPU9150.c
  group SvVis_Library
    ./: SvVis3.c
software components: CMSIS:CORE 5.6.0, HTL Hollabrunn:Libraries:I2CLib 1.0.0, HTL Hollabrunn:Libraries:STDLib 3.1.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0
